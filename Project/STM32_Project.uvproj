# Keil uVision project STM32_Project.uvproj, settings and files
target FGZ_STM32_FMU (ARM-ADS)
  device: STM32F405VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32_Project +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\Startup;..\User;..\FW;..\Output;..\Listing;..\Doc;..\Sensors;..\AHRS;..\MCU_System;..\Control;..\CommonDeal;..\PX4;..\INS_GPS_Navigation
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../Startup/: startup_stm32f4xx.s
  group CMSIS
    ../CMSIS/: arm_common_tables.h arm_math.h core_cm0.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group FW
    ../FW/: misc.c misc.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_can.c stm32f4xx_can.h stm32f4xx_crc.c stm32f4xx_crc.h stm32f4xx_cryp.c stm32f4xx_cryp.h stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dac.h stm32f4xx_dbgmcu.c stm32f4xx_dbgmcu.h stm32f4xx_dcmi.c stm32f4xx_dcmi.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_flash.c stm32f4xx_flash.h stm32f4xx_fsmc.c stm32f4xx_fsmc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_hash.c stm32f4xx_hash.h stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_iwdg.c stm32f4xx_iwdg.h stm32f4xx_pwr.c stm32f4xx_pwr.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_rng.c stm32f4xx_rng.h stm32f4xx_rtc.c stm32f4xx_rtc.h stm32f4xx_sdio.c stm32f4xx_sdio.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_usart.c stm32f4xx_usart.h stm32f4xx_wwdg.c stm32f4xx_wwdg.h
  group User
    ../User/: main.c system_stm32f4xx.c stm32f4xx_conf.h
  group MCU_System
    ../MCU_System/: delay.c delay.h My_I2C.c My_I2C.h My_LED.c My_LED.h My_Flash.c My_Flash.h My_Timer.c My_Timer.h My_OLED.c My_OLED.h My_USART.c My_USART.h System_INIT.c System_Events.c Global_Variable.c Global_Variable.h System_Common.h System_All_Head.h
  group Sensors
    ../Sensors/: L3GD20.c L3GD20.h MS5611.c MS5611.h LSM303D.c LSM303D.h MPU6050.c MPU6050.h HC_SR04.c HC_SR04.h HMC5883L.c HMC5883L.h GPS_NEO_M8N.c GPS_NEO_M8N.h
  group CommonDeal
    ../CommonDeal/: CommonPlan.c CommonPlan.h CommonConversions.c CommonConversions.h
  group AHRS
    ../AHRS/: QCF_Attitude.c QCF_Attitude.h EKF_Attitude.c EKF_Attitude.h EKF_MAG_Fusion.c EKF_MAG_Fusion.h
  group INS_GPS_Navigation
    ../INS_GPS_Navigation/: EKF_INS_GPS_Estimator.c EKF_INS_GPS_Estimator.h
  group Control
    ../Control/: pid.c pid.h AttitudeControl.c AttitudeControl.h PositionControl.c PositionControl.h
